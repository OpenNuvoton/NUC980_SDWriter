# Keil uVision project SD_Writer.uvproj, settings and files
target SD_Writer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SD_Writer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\Driver\Include;..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x70000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group User
    ./: main.c diskio.c SDGlue.c ProcessIni.c spiflash.c sdglue2.c sd.c spinandflash.c nand.c filesystem.c
  group Libraries
    ../../Driver/Source/: sys.c sdh.c cache.c retarget.c vector.s startup.s etimer.c gpio.c qspi.c
  group FATFS
    ../../ThirdParty/FatFs/src/: ff.c
    ../../ThirdParty/FatFs/src/option/: cc932.c
